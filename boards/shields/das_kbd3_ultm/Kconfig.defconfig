## boards/shields/das_kbd3_ultm/Kconfig.defconfig
```kconfig
if SHIELD_DAS_KBD3_ULTM

config ZMK_KEYBOARD_NAME
    default "das-kbd3-ultm"

endif # SHIELD_DAS_KBD3_ULTM
```
